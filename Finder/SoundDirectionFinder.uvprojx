# Keil uVision project SoundDirectionFinder.uvprojx, settings and files
target STM32F334x8 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F334K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F334x8
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F334x8
  c misc: --C99
  c include: .\src;.\src\Main;.\Device;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\Libraries\STM32F30x_StdPeriph_Driver\inc;.\Libraries\STM32F30x_I2C_CPAL_Driver\inc;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\src\Usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Device
    ./Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f303xc.s startup_stm32f303xe.s startup_stm32f302x8.s startup_stm32f334x8.s
    ./Device/: stm32f30x_it.c system_stm32f30x.c
  group STM32F30x_StdPeriph_Driver
    ./Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dma.c stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_exti.c stm32f30x_misc.c stm32f30x_syscfg.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_wwdg.c
  group Main
    ./src/Main/: main.c config.h
  group Drivers
    ./src/Drivers/gpio/: gpio.c discovery_leds.h
    ./src/Drivers/uart/: uart.c
    ./src/Drivers/delay/: delay.c
    ./src/Drivers/adc/: adc.c
  group USB_LIB
    ./Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_USR
    ./src/Usb/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_conf.h stm32_it.c stm32303c_eval.c
target STM32F302x8 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F302x8
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F302x8
  c misc: --C99
  c include: .\src;.\src\Main;.\Device;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\Libraries\STM32F30x_StdPeriph_Driver\inc;.\Libraries\STM32F30x_I2C_CPAL_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
target STM32F303xC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303xC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xC,USE_STM32303C_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
target STM32F303xE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303xE
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xE,USE_STM32303C_EVAL
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
